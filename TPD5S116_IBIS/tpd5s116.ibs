| From tpd5s116.ibs, TPD5S116, Texas Instruments
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[Model]   en_1p5v
Model_type   Input
Vinl = 0.4
Vinh = 1
|   typ   min   max
|   (nom PVT)   (slow PVT)   (fast PVT)
C_comp   0.787p   0.739p   0.858p
| Where nom  PVT is Nominal Process, 1.5V, 27C
|   Fast PVT is Strong Process,  1.65V, -40C
|   Slow PVT is Weak Process,   1.35V, 125C
[Voltage Range]   1.5   1.35   1.65
[Temperature Range]   27   125   -40
[Power Clamp Reference]   1.5   1.35   1.65
[GND Clamp Reference]   -0   -0   -0
| Worked out from all points:
|   GND clamp passes 1 mA (typ) near -0.67 V on its own axis
[GND Clamp]
|   Voltage   I(typ)   I(min)   I(max)
-1.5V     -519.1mA   -602.9mA   -466.6mA
-1.202V   -242.5mA   -327.3mA   -189mA
-1.113V   -164.5mA   -248.3mA   -112.2mA
-1.112V   -163.6mA   -247.4mA   -111.3mA
-1.022V   -90.62mA   -170.9mA   -44.98mA
-932.8mV  -32.5mA    -100.8mA   -12.64mA
-843.4mV  -7.124mA   -43.03mA   -6.21mA
-752.8mV  -2.377mA   -10.12mA   -2.754mA
-663.4mV  -813.2uA   -1.808mA   -815uA
-573.4mV  -188.4uA   -395.3uA   -141uA
-483.4mV  -31.48uA   -86.43uA   -17.23uA
3V        0A         0A         0A
[POWER Clamp]
|   Voltage   I(typ)   I(min)   I(max)
-1.5V     122.2pA    4.398nA    56.84pA
-1.5V     0A         0A         0A
-1.5V     0A         0A         0A
3V        0A         0A         0A
