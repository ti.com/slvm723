| From tpd5s116.ibs, TPD5S116, Texas Instruments
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[Model]   en_5v
Model_type   Input
Vinl = 0.4
Vinh = 1
|   typ   min   max
|   (nom PVT)   (slow PVT)   (fast PVT)
C_comp   0.787p   0.739p   0.858p
| Where nom  PVT is Nominal Process, 5V, 27C
|   Fast PVT is Strong Process,  5.5V, -40C
|   Slow PVT is Weak Process,   4.5V, 125C
[Voltage Range]   5   4.5   5.5
[Temperature Range]   27   125   -40
[Power Clamp Reference]   5   4.5   5.5
[GND Clamp Reference]   -0   -0   -0
| Worked out from all points:
|   GND clamp passes 1 mA (typ) near -0.67 V on its own axis
[GND Clamp]
|   Voltage   I(typ)   I(min)   I(max)
-5V       -3.964A    -4.035A    -3.921A
-1.29V    -322.6mA   -406.7mA   -270.3mA
-1.009V   -82.04mA   -161.5mA   -37.43mA
-1V       -74.25mA   -153.6mA   -35.08mA
-989.6mV  -69.91mA   -144.3mA   -32.34mA
-901mV    -33.59mA   -88.18mA   -9.418mA
-834mV    -6.116mA   -45.73mA   -6.121mA
-796.7mV  -4.936mA   -22.09mA   -4.285mA
-667.9mV  -861.8uA   -7.77mA    -981.1uA
-603.8mV  -779.7uA   -653uA     -396.9uA
-379.7mV  -492.2uA   -13.53uA   -2.51uA
10V       0A         0A         0A
[POWER Clamp]
|   Voltage   I(typ)   I(min)   I(max)
-5V       1.36nA     68.98nA    203.2pA
-5V       0A         40.23nA    0A
-5V       0A         38.66nA    0A
-5V       0A         33.4nA     0A
-5V       0A         29.45nA    0A
-4.999V   0A         25.71nA    0A
-4.998V   0A         23.94nA    0A
-4.985V   0A         24.28nA    0A
-4.726V   0A         14.09nA    0A
-4.453V   0A         4.824nA    0A
-3.99V    0A         0A         0A
10V       0A         0A         0A
