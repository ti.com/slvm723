| From tpd5s116.ibs, TPD5S116, Texas Instruments
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[Model]   en_2p5v
Model_type   Input
Vinl = 0.4
Vinh = 1
|   typ   min   max
|   (nom PVT)   (slow PVT)   (fast PVT)
C_comp   0.787p   0.739p   0.858p
| Where nom  PVT is Nominal Process, 2.5V, 27C
|   Fast PVT is Strong Process,  2.75V, -40C
|   Slow PVT is Weak Process,   2.25V, 125C
[Voltage Range]   2.5   2.25   NA
[Temperature Range]   27   125   NA
[Power Clamp Reference]   2.5   2.25   NA
[GND Clamp Reference]   -0   -0   NA
| Worked out from all points:
|   GND clamp passes 1 mA (typ) near -0.67 V on its own axis
[GND Clamp]
|   Voltage   I(typ)   I(min)   I(max)
-2.5V     -1.49A     -1.569A    NA
-1.058V   -118.7mA   -201.2mA   NA
-911.9mV  -24.04mA   -85.73mA   NA
-908.4mV  -21.78mA   -84.01mA   NA
-761.9mV  -2.972mA   -11.95mA   NA
-758.4mV  -2.522mA   -11.69mA   NA
-664.3mV  -820.3uA   -4.662mA   NA
-611.9mV  -461.2uA   -746.4uA   NA
-408.7mV  -9.809uA   -23.06uA   NA
5V        0A         0A         NA
[POWER Clamp]
|   Voltage   I(typ)   I(min)   I(max)
-2.5V     181.8pA    6.023nA    NA
-2.5V     0A         0A         NA
-2.5V     0A         0A         NA
5V        0A         0A         NA
